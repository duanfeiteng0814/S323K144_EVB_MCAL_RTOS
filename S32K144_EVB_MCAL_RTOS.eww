<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\S32K144_EVB_MCAL_RTOS.ewp</path>
    </project>
    <batchBuild />
</workspace>
