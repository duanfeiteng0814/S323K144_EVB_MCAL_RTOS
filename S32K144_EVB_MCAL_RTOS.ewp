# IAR project S32K144_EVB_MCAL_RTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __ICCARM__; CPU_S32K144HFT0VLLT; AUTOSAR_OS_NOT_USED
  ICCARM.CCIncludePath2: platform\devices; platform\devices\S32K144; platform\devices\S32K144\include; platform\devices\S32K144\startup; platform\devices\S32K144\startup\iar; MCALCommon\Base\include; MCALCommon\Dio\include; MCALCommon\Dio\src; MCALCommon\Port\include; MCALCommon\Port\src; MCALCommon\Det\include; MCALCommon\Det\src; MCALCommon\Rte\include; MCALCommon\Rte\src; MCALConfiguration\include; MCALConfiguration\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S32K144_EVB_MCAL_RTOS.srec
  ILINK.IlinkOutputFile: S32K144_EVB_MCAL_RTOS.out
  ILINK.IlinkIcfFile: D:\workspaces\S32K144_EVB_MCAL_RTOS\S32K146.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group MCALCommon/Base/include
    MCALCommon/Base/include/: Adc_MemMap.h Can_GeneralTypes.h Can_MemMap.h Compiler.h Compiler_Cfg.h CompilerDefinition.h ComStack_Cfg.h ComStack_Types.h Crcu_MemMap.h Crypto_MemMap.h Csec_MemMap.h Dio_MemMap.h Eep_MemMap.h Eth_GeneralTypes.h Eth_MemMap.h EthSwitch_43_SJA1105P_MemMap.h EthSwt_43_SJA1110_MemMap.h EthTrcv_43_TJA110X_MemMap.h Fee_MemMap.h Fls_MemMap.h Fr_GeneralTypes.h Fr_MemMap.h Gpt_MemMap.h I2c_MemMap.h Icu_MemMap.h Iseled_MemMap.h Lin_GeneralTypes.h Lin_MemMap.h Mcal.h Mcem_MemMap.h Mcl_MemMap.h Mcu_MemMap.h Ocu_MemMap.h Platform_Types.h Port_MemMap.h Pwm_MemMap.h Reg_eSys.h RegLockMacros.h SilRegMacros.h Spi_MemMap.h Std_Types.h StdRegMacros.h Wdg_MemMap.h
  group MCALCommon/Det/include
    MCALCommon/Det/include/: Det.h
  group MCALCommon/Det/src
    MCALCommon/Det/src/: Det.c
  group MCALCommon/Dio/include
    MCALCommon/Dio/include/: Dio.h Dio_EnvCfg.h Dio_Gpio.h Dio_Ipw.h Reg_eSys_Gpio.h
  group MCALCommon/Dio/src
    MCALCommon/Dio/src/: Dio.c Dio_Gpio.c
  group MCALCommon/Port/include
    MCALCommon/Port/include/: Port.h Port_EnvCfg.h Port_Ipw.h Port_Port_Ci.h Port_Port_Ci_Types.h Port_Reg_eSys_Port_Ci.h Reg_eSys_Gpio.h
  group MCALCommon/Port/src
    MCALCommon/Port/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group MCALCommon/Rte/include
    MCALCommon/Rte/include/: SchM_Adc.h SchM_Can.h SchM_Crcu.h SchM_Dio.h SchM_Eep.h SchM_Eth.h SchM_Fee.h SchM_Fls.h SchM_Fr.h SchM_Gpt.h SchM_I2c.h SchM_Icu.h SchM_Iseled.h SchM_Lin.h SchM_Mcem.h SchM_Mcl.h SchM_Mcu.h SchM_Ocu.h SchM_Port.h SchM_Pwm.h SchM_RamTst.h SchM_Spi.h SchM_Wdg.h
  group MCALCommon/Rte/src
    MCALCommon/Rte/src/: SchM_Adc.c SchM_Can.c SchM_Crcu.c SchM_Dio.c SchM_Eep.c SchM_Eth.c SchM_Fee.c SchM_Fls.c SchM_Fr.c SchM_Gpt.c SchM_I2c.c SchM_Icu.c SchM_Iseled.c SchM_Lin.c SchM_Mcem.c SchM_Mcl.c SchM_Mcu.c SchM_Ocu.c SchM_Port.c SchM_Pwm.c SchM_RamTst.c SchM_Spi.c SchM_Wdg.c
  group MCALConfiguration/include
    MCALConfiguration/include/: Dio_Cfg.h modules.h Port_Cfg.h Soc_Ips.h
  group MCALConfiguration/output
    MCALConfiguration/output/: Base.epc Dio.epc Port.epc Resource.epc
  group MCALConfiguration/src
    MCALConfiguration/src/: Dio_Cfg.c Port_Cfg.c Port_PBcfg.c
  group MCALTresosConfiguration/config
    MCALTresosConfiguration/config/: Base.xdm Dio.xdm Port.xdm Resource.xdm SystemModel2.tdb
  group platform/devices
    platform/devices/: callbacks.h devassert.h device_registers.h startup.c startup.h status.h
  group platform/devices/S32K144/include
    platform/devices/S32K144/include/: readme.h S32K144.h S32K144_features.h
  group platform/devices/S32K144/linker
    platform/devices/S32K144/linker/iar/: S32K144_64_flash.icf S32K144_64_ram.icf
  group platform/devices/S32K144/startup
    platform/devices/S32K144/startup/iar/: startup_S32K144.s
    platform/devices/S32K144/startup/: system_S32K144.c system_S32K144.h
